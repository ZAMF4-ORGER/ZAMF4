# Keil uVision project STM32F4-DEMO.uvprojx, settings and files
target DEMO (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4-DEMO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\DRIVER;..\MAIN;..\STM32F4xx_StdPeriph_Driver\inc;..\CMSIS-Include;..\PERPH;..\RADAR
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
  group DRIVER
    ../DRIVER/AD/: ad.c
    ../DRIVER/DAC/: da.c
    ../DRIVER/USART/: usart.c
    ../DRIVER/FLASH/: flash.c
    ../DRIVER/DELAY/: delay.c
  group MAIN
    ../MAIN/: main.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group PERPH
    ../PERPH/LED/: led.c
    ../PERPH/RELAY/: relay.c
  group BasicMathFunctions
    ../DSP_LIB/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
  group CommonTables
    ../DSP_LIB/CommonTables/: arm_common_tables.c arm_const_structs.c
  group ComplexMathFunctions
    ../DSP_LIB/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group ControllerFunctions
    ../DSP_LIB/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group FastMathFunctions
    ../DSP_LIB/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group FilteringFunctions
    ../DSP_LIB/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q7.c arm_conv_opt_q15.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q7.c arm_conv_partial_opt_q15.c arm_conv_partial_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_q7.c arm_conv_q15.c arm_conv_q31.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q7.c arm_correlate_opt_q15.c arm_correlate_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q7.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q7.c arm_fir_q15.c arm_fir_q31.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q7.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group MatrixFunctions
    ../DSP_LIB/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group StatisticsFunctions
    ../DSP_LIB/StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group SupportFunctions
    ../DSP_LIB/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
  group TransformFunctions
    ../DSP_LIB/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c arm_bitreversal2.S
  group ARM
    ../DSP_LIB/ARM/: arm_cortexM4b_math.lib arm_cortexM4bf_math.lib arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group RADAR
    ../RADAR/: FastMath.c fft.c radar_dete.c double.c
